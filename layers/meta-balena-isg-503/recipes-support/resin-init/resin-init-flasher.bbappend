# support emmc
INTERNAL_DEVICE_KERNEL = "mmcblk1"